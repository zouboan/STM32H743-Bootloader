# Keil uVision project Project.uvprojx, settings and files
target BootH7 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: BootH7 +hex
  AfterMake: fromelf --bin --output ../MDK-ARM/BootH7/BootH7.bin ../MDK-ARM/BootH7/BootH7.axf
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32H743xx,USE_HAL_DRIVER,USE_USB_FS
  c misc: --C99
  c include: ../Inc;../../STM32Drivers/CMSIS/Include;../../STM32Drivers/CMSIS/Device/STM32H7xx/Include;../../STM32Drivers/STM32H7xx_HAL_Driver/Inc;../../Middlewares/STM32_USB_Device_Library/Core/Inc;../../Middlewares/STM32_USB_Device_Library/Class/CDC/Inc;../../STM32Drivers/BSP/FMU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/User
    ../Src/: usbd_conf.c stm32h7xx_it.c usbd_cdc_interface.c usbd_desc.c stm32h7xx_hal_msp.c main.c
  group CMSIS
    ../Src/: system_stm32h7xx.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group STM32Drivers/STM32H7xx_Driver
    ../../STM32Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_cortex.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_tim.c stm32h7xx_hal_uart.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c
  group Middlewares/STM32_USBD_Library/Class/CDC
    ../../Middlewares/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/STM32_USBD_Library/Core
    ../../Middlewares/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_ioreq.c usbd_core.c
  group STM32Drivers/BSP/FMU
    ../../STM32Drivers/BSP/FMU/: fmu.c
software components: CMSIS:CORE 5.1.2
